# Keil uVision project BlueSkyFlightControl.uvprojx, settings and files
target BlueSkyFlightControl (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: BlueSky +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__CC_ARM,__FPU_PRESENT,USE_USB_OTG_FS
  c misc: --c99
  c include: ..\PROJECT;..\FWLIB;..\SRC\DRIVER;..\SRC\SYSTEM;..\SRC\MATH;..\SRC\MODULE;..\SRC\SENSOR;..\SRC\NAVIGATION;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\SRC\TASK;..\SRC\USBHID;..\SRC\DATA;..\SRC\CONTROL;..\STMLIB\inc;..\STMLIB\Include;..\STMLIB\CORE;..\STMLIB\USBStack\INC;..\STMLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../SRC/: main.c
  group TASK
    ../SRC/TASK/: TaskConfig.h module_task.c module_task.h messageQueue.c messageQueue.h
  group MATH
    ../SRC/MATH/: mathTool.c mathTool.h vector3.c vector3.h matrix3.c matrix3.h kalman3.c kalman3.h pid.c pid.h
  group MODULE
    ../SRC/MODULE/: module.c module.h mpu6000.c mpu6000.h ms5611.c ms5611.h qmc5883.c qmc5883.h
  group DRIVER
    ../SRC/DRIVER/: boardConfigBlueSkyV3.h board.c board.h drv_spi.c drv_spi.h drv_usart.c drv_usart.h drv_i2c_soft.c drv_i2c_soft.h
  group STMLIB
    ../STMLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c
    ../STMLIB/: stm32f4xx_it.c system_stm32f4xx.c
    ../STMLIB/CORE/: startup_stm32f40_41xxx.s
  group FreeRTOS
    ../FreeRTOS/Source/: tasks.c queue.c list.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/include/: FreeRTOSConfig.h
